#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " peekpoke"
IMAGE_INSTALL_append = " gpio-demo"
IMAGE_INSTALL_append = " memdump"
IMAGE_INSTALL_append = " getjpeg"
IMAGE_INSTALL_append = " hidgadgettest"
IMAGE_INSTALL_append = " webmouse"
